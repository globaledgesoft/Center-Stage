# IAR project QCA402X_AWS.ewp, settings and files
configuration FreeRTOS (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_SPPLE_DEMO; CONFIG_HMI_DEMO; CONFIG_WIFI_DEMO; CONFIG_NET_DEMO; CONFIG_COEX_DEMO; CONFIG_FWUP_DEMO; CONFIG_ADSS_DEMO; CONFIG_LP_DEMO; CONFIG_FS_DEMO; CONFIG_SECUREFS_DEMO; CONFIG_CRYPTO_DEMO; CONFIG_CRYPTO_UNIT_TEST_DEMO; CONFIG_ZIGBEE_DEMO; CONFIG_PERIPHERALS_DEMO; CONFIG_PLATFORM_DEMO; HTC_SYNC; __FILENAME__="abc"; V2; FEATURE_QUARTZ_V2; qurt_mutex_init(x)=qurt_mutex_create(x); qurt_mutex_destroy(x)=qurt_mutex_delete(x); qurt_signal_init(x)=qurt_signal_create(x); qurt_signal_destroy(x)=qurt_signal_delete(x); AWS_IOT; CONFIG_ECOSYSTEM_DEMO
  ICCARM.CCDiagSuppress: Pa050,Pe066,Pe068,Pe549, Pe236,Pe111,Pe144,Pe167,Pe177,Pe186,Pe188,Pe513,Pe009,Pe546,Pe223,Pe550,Pe940
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\include\qapi; ..\..\..\..\..\include\bsp; ..\..\..\..\..\quartz\m4_common\nvm\inc; ..\..\src\adss; ..\..\src\boot; ..\..\src\coex; ..\..\src\crypto; ..\..\src\fs; ..\..\src\hmi; ..\..\src\lp; ..\..\src\net; ..\..\src\ota; ..\..\src\qcli; ..\..\src\securefs; ..\..\src\spple; ..\..\src\spple\ota; ..\..\src\thread; ..\..\src\wifi; ..\..\src\zigbee; ..\..\src\zigbee\clusters; ..\..\src\sensors; ..\..\src\adc; ..\..\src\pwm; ..\..\src\keypad; ..\..\src\cpp; ..\..\src\peripherals; ..\..\src\platform; ..\..\src\ecosystem; ..\..\src\enc; ..\..\src\master_sdcc; ..\..\..\..\..\thirdparty\aws\awsiot\include; ..\..\..\..\..\quartz\ecosystem\aws\port\include; ..\..\src\ecosystem\aws\shadow_sample; ..\..\src; ..\..\src\htc_slave; ..\..\src\targetif\include; ..\..\src\targetif\htc\include; ..\..\src\targetif\hif; ..\..\src\targetif\osal; ..\..\src\targetif\transport\qurt; ..\..\src\targetif\transport\qurt\sdio; ..\..\src\targetif\transport\qurt\spi; ..\..\src\targetif\app; ..\..\src\kpi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Quartz.srec
  prebuild: prepare.bat 4020
  postbuild: python ..\..\..\..\..\build\scripts\createxbl.py -foutput\Exe\Quartz.elf -a32 -ooutput\Exe\Quartz_HASHED.elf
  ILINK.IlinkOutputFile: Quartz.elf
  ILINK.IlinkKeepSymbols: qca_init; ram_function_table; ram_function_table_som; ram_function_table_mom; quartz_ram_function_table; vectTable; som_indirection_table; mom_indirection_table; fom_indirection_table; DALPROP_PropsInfo_qca4020_devcfg_xml; DALPROP_StructPtrs_qca4020_fom_xml; DALPROP_PropsInfo_qca4020_fom_xml; Image$$RAM_FOM_BSP_ZI_REGION$$ZI$$Base
  ILINK.IlinkIcfFile: linkerCfg\v2\freertos\Quartz.icf
  ILINK.IlinkExtraOptions: -f "..\..\..\..\..\bin\cortex-m4\IOE_ROM_IPT_IMG_ARNNRI_iar.sym"; -f "..\..\..\..\..\bin\cortex-m4\IOE_ROM_IPT_IMG_ARNNRI_orig_fcns_iar.sym"; --loadable
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\lib\cortex-m4IPT\freertos\free_rtos.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\mom_patch_table_ARNFRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\freertos\fom_patch_table_ARNFRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\freertos\som_patch_table_ARNFRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\freertos\qurt.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\core.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\v2core.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\quartzplatform.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\WLAN.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\CUST_IPSTACK_INICHE.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\WLAN_PROFILER.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\net.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\net_ram.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\dhcpv6c.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\sntpc.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\dnssrvr.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\sharkssl.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\cryptolib.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\httpsvr.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\vfs.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\userpass.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\i2s.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\fwup.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\fwup_engine.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\nichestack.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\qapi_ed25519.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\qapi_securefs.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\pka_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\fs_helper.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\zigbee.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\quartz_zigbee.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\patch.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\BLUETOPIA_SERVICES.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\BLUETOPIA_QAPI_SERVICES.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\mdns.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\WLAN_QAPI.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\wlan_lib_common_xip.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\cust_wlan_lib.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\httpc.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\dnssd.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\quartzplatform_xip.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\mqttc.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\base64.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\PERSIST_M4.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\json.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\json_qapi.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\otp_tlv.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\EDLManager.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\tlv_transport.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\crypto_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\tee_master.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\dnsclient.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\securefs.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\securefs_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\QCA4020_2p0_C_NVM.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\quartz_crypto_qapi.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\master_sdcc.lib; ..\..\..\..\..\lib\cortex-m4IPT\freertos\csr.lib
  ILINK.IlinkProgramEntryLabel: SBL_Entry
configuration Threadx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_SPPLE_DEMO; CONFIG_HMI_DEMO; CONFIG_WIFI_DEMO; CONFIG_NET_DEMO; CONFIG_COEX_DEMO; CONFIG_FWUP_DEMO; CONFIG_ADSS_DEMO; CONFIG_LP_DEMO; CONFIG_FS_DEMO; CONFIG_SECUREFS_DEMO; CONFIG_CRYPTO_DEMO; CONFIG_CRYPTO_UNIT_TEST_DEMO; CONFIG_ZIGBEE_DEMO; CONFIG_PERIPHERALS_DEMO; CONFIG_PLATFORM_DEMO; HTC_SYNC; __FILENAME__="abc"; V2; FEATURE_QUARTZ_V2; qurt_mutex_init(x)=qurt_mutex_create(x); qurt_mutex_destroy(x)=qurt_mutex_delete(x); qurt_signal_init(x)=qurt_signal_create(x); qurt_signal_destroy(x)=qurt_signal_delete(x)
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\include\qapi; ..\..\..\..\..\include\bsp; ..\..\..\..\..\quartz\m4_common\nvm\inc; ..\..\src\adss; ..\..\src\boot; ..\..\src\coex; ..\..\src\crypto; ..\..\src\fs; ..\..\src\hmi; ..\..\src\lp; ..\..\src\net; ..\..\src\ota; ..\..\src\qcli; ..\..\src\securefs; ..\..\src\spple; ..\..\src\spple\ota; ..\..\src\thread; ..\..\src\wifi; ..\..\src\zigbee; ..\..\src\sensors; ..\..\src\adc; ..\..\src\pwm; ..\..\src\keypad; ..\..\src\cpp; ..\..\src\peripherals; ..\..\src\platform; ..\..\src\ecosystem; ..\..\src\enc; ..\..\src\zigbee\clusters; ..\..\src\master_sdcc; ..\..\..\..\..\thirdparty\aws\awsiot\include; ..\..\..\..\..\quartz\ecosystem\aws\port\include; ..\..\src\ecosystem\aws\shadow_sample; ..\..\src; ..\..\src\htc_slave; ..\..\src\targetif\include; ..\..\src\targetif\htc\include; ..\..\src\targetif\hif; ..\..\src\targetif\osal; ..\..\src\targetif\transport\qurt; ..\..\src\targetif\transport\qurt\sdio; ..\..\src\targetif\transport\qurt\spi; ..\..\src\targetif\app; ..\..\src\kpi
  ILINK.IlinkIcfFile: linkerCfg\v2\threadx\Quartz.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\lib\cortex-m4IPT\threadx\threadx.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\mom_patch_table_ARNTRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\threadx\fom_patch_table_ARNTRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\threadx\som_patch_table_ARNTRI_qcm.o; ..\..\..\..\..\lib\cortex-m4IPT\threadx\qurt.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\core.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\v2core.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\quartzplatform.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\WLAN.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\CUST_IPSTACK_INICHE.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\WLAN_PROFILER.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\net.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\net_ram.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\dhcpv6c.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\sntpc.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\dnssrvr.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\sharkssl.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\cryptolib.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\httpsvr.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\vfs.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\userpass.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\i2s.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\fwup.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\fwup_engine.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\nichestack.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\qapi_ed25519.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\qapi_securefs.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\pka_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\fs_helper.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\zigbee.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\quartz_zigbee.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\patch.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\BLUETOPIA_SERVICES.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\BLUETOPIA_QAPI_SERVICES.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\mdns.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\WLAN_QAPI.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\wlan_lib_common_xip.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\cust_wlan_lib.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\httpc.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\dnssd.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\quartzplatform_xip.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\mqttc.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\base64.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\PERSIST_M4.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\json.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\json_qapi.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\EDLManager.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\tlv_transport.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\otp_tlv.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\crypto_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\tee_master.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\dnsclient.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\securefs.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\securefs_port.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\QCA4020_2p0_C_NVM.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\quartz_crypto_qapi.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\master_sdcc.lib; ..\..\..\..\..\lib\cortex-m4IPT\threadx\csr.lib
  group (top)
    ../../src/: sbrk.c unistd.h
  group adc
    ../../src/adc/: adc.c adc_demo.c
  group adss
    ../../src/adss/: adss.c adss_audio_data.c adss_demo.c adss_demo.h adss_ftp.c adss_ftp_rec.c adss_mem.c adss_pcm.c
  group aws_port
    ../../../../ecosystem/aws/port/: network_qca4020_wrapper.c timer.c
  group aws_port/include
    ../../../../ecosystem/aws/port/include/: network_interface.h network_platform.h threads_interface.h timer_interface.h timer_platform.h
  group coex
    ../../src/coex/: coex_demo.c coex_demo.h
  group crypto
    ../../src/crypto/: crypto_demo.c crypto_demo.h crypto_helper.c crypto_helper.h persistent_obj_demo.c persistent_obj_demo.h
  group ecosystem
    ../../src/ecosystem/: ecosystem_demo.c ecosystem_demo.h
  group ecosystem/aws
    ../../src/ecosystem/aws/shadow_sample/: shadow_sample.c shadow_sample.h
  group enc
    ../../src/enc/: json_demo.c json_demo.h
  group export
    ../../src/export/: DALConfig_devcfg.c DALConfig_fom.c devcfg_devcfg_data.c devcfg_fom_data.c platform_oem.c platform_oem.h platform_oem_mom.c platform_oem_som.c UsrEDL.c
  group fs
    ../../src/fs/: fs_demo.c fs_demo.h
  group hmi
    ../../src/hmi/: hmi_demo.c hmi_demo.h
  group htc_slave
    ../../src/htc_slave/: htc_slave_demo.c htc_slave_demo.h
  group lp
    ../../src/lp/: fom_lp_test.c lp_demo.c lp_demo.h mom_lp_test.c om_lp_test.h platform_oem.h som_lp_test.c
  group master_sdcc
    ../../src/master_sdcc/: master_sdcc.c master_sdcc_demo.c
  group net
    ../../src/net/: bench.c bench.h bench_raw.c bench_ssl.c bench_tcp.c bench_uapsd.c bench_udp.c cert_demo.c eth_raw.c httpc_demo.c iperf.c mqttc_demo.c net_demo.h netcmd.c netutils.c netutils.h ssl_demo.c
  group net/httpsvr/cgi
    ../../src/net/httpsvr/cgi/: cgi_demo.c cgi_showintf.c htmldata.c htmldata.h
  group ota
    ../../src/ota/: ota_demo.c ota_demo.h
  group ota/plugins/ble
    ../../src/ota/plugins/ble/: ota_ble.c ota_ble.h
  group ota/plugins/ftp
    ../../src/ota/plugins/ftp/: ota_ftp.c ota_ftp.h
  group ota/plugins/http
    ../../src/ota/plugins/http/: ota_http.c ota_http.h
  group ota/plugins/zigbee
    ../../src/ota/plugins/zigbee/: ota_zigbee.c ota_zigbee.h
  group peripherals
    ../../src/peripherals/: peripherals_demo.c
  group platform
    ../../src/platform/: platform_demo.c platform_demo.h
  group pwm
    ../../src/pwm/: pwm.c pwm_demo.c
  group keypad
    ../../src/keypad/: keypad.c keypad_demo.c
  group qcli
    ../../src/qcli/: EDLFile.h pal.c pal.h qcli.c qcli.h qcli_api.h qcli_util.c qcli_util.h
  group securefs
    ../../src/securefs/: securefs_demo.c securefs_demo.h
  group sensors
    ../../src/sensors/: sensors.c sensors_demo.c
  group spple
    ../../src/spple/: spple_demo.c spple_demo.h spple_types.h
  group spple/ota
    ../../src/spple/ota/: ble_ota_service.c ble_ota_service.h ble_ota_service_types.h
  group targetif/app
    ../../src/targetif/app/: htc_demo.c htc_demo.h
  group targetif/hif
    ../../src/targetif/hif/: hif.c hif_internal.h
  group targetif/htc/include
    ../../src/targetif/htc/include/: htc_internal.h
  group targetif/htc/src
    ../../src/targetif/htc/src/: htc.c htc_events.c htc_recv.c htc_send.c htc_utils.c
  group targetif/include
    ../../src/targetif/include/: dl_list.h hif.h htc.h htc_defs.h htc_host_reg.h
  group targetif/osal
    ../../src/targetif/osal/: osal_types.h
  group targetif/transport/quart
    ../../src/targetif/transport/qurt/: transport.c transport.h
  group targetif/transport/quart/sdio
    ../../src/targetif/transport/qurt/sdio/: sdio.c sdio.h sdio_hal_api.h
  group targetif/transport/quart/spi
    ../../src/targetif/transport/qurt/spi/: spi_hal.c spi_hal.h spi_hal_api.h
  group thirdparty
    ../../../../../thirdparty/aws/awsiot/: aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c jsmn.c
  group thirdparty/include
    ../../../../../thirdparty/aws/awsiot/include/: aws_iot_config.h aws_iot_error.h aws_iot_json_utils.h aws_iot_log.h aws_iot_mqtt_client.h aws_iot_mqtt_client_common_internal.h aws_iot_mqtt_client_interface.h aws_iot_shadow_actions.h aws_iot_shadow_interface.h aws_iot_shadow_json.h aws_iot_shadow_json_data.h aws_iot_shadow_key.h aws_iot_shadow_records.h aws_iot_version.h jsmn.h
  group wifi
    ../../src/wifi/: util.c util.h wifi_cmd_handler.c wifi_demo.c wifi_demo.h
  group zigbee
    ../../src/zigbee/: zcl_demo.c zcl_demo.h zdp_demo.c zdp_demo.h zigbee_demo.c zigbee_demo.h
  group zigbee/clusters
    ../../src/zigbee/clusters/: zcl_alarms_demo.c zcl_alarms_demo.h zcl_ballast_demo.c zcl_ballast_demo.h zcl_basic_demo.c zcl_basic_demo.h zcl_colorcontrol_demo.c zcl_colorcontrol_demo.h zcl_custom_demo.c zcl_custom_demo.h zcl_devicetemp_demo.c zcl_devicetemp_demo.h zcl_doorlock_demo.c zcl_doorlock_demo.h zcl_fancontrol_demo.c zcl_fancontrol_demo.h zcl_groups_demo.c zcl_groups_demo.h zcl_iasace_demo.c zcl_iasace_demo.h zcl_iaswd_demo.c zcl_iaswd_demo.h zcl_iaszone_demo.c zcl_iaszone_demo.h zcl_identify_demo.c zcl_identify_demo.h zcl_illuminance_demo.c zcl_illuminance_demo.h zcl_levelcontrol_demo.c zcl_levelcontrol_demo.h zcl_occupancy_demo.c zcl_occupancy_demo.h zcl_onoff_demo.c zcl_onoff_demo.h zcl_ota_demo.c zcl_ota_demo.h zcl_powerconfig_demo.c zcl_powerconfig_demo.h zcl_relhumid_demo.c zcl_relhumid_demo.h zcl_scenes_demo.c zcl_scenes_demo.h zcl_tempmeasure_demo.c zcl_tempmeasure_demo.h zcl_thermostat_demo.c zcl_thermostat_demo.h zcl_time_demo.c zcl_time_demo.h zcl_touchlink_demo.c zcl_touchlink_demo.h zcl_wincover_demo.c zcl_wincover_demo.h
